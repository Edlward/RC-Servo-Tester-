# Keil uVision project servo_tester.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: servo_tester +hex
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030X4,
  c include: .\Source;.\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\Libraries\CMSIS\Include;..\Servo_Tester_v4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group 1
    ./: startup_stm32f030.s
  group Source
    ./Source/: main.c board.h stm32f0xx_it.c stm32f0xx_it.h drv_system.c drv_system.h drv_uart.c drv_uart.h drv_adc.h drv_adc.c drv_pwm.h drv_pwm.c drv_keyInput.c drv_keyInput.h config.c config.h drv_timer.c drv_timer.h queue.c queue.h
  group STM32F0xx_StdPeriph_Driver
    ./Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CMICS
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Include/: stm32f0xx.h system_stm32f0xx.h
    ./Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
